# Repository robbederks/olchanowski

File README.md:

# Olchanowski
## Fixing the Zortrax M200 electronics
The Zortrax M200's mechanical design is great. It's electronics and software is not.
Let's fix that!

### Checklist
- [X] Processor
- [X] 4 stepper drivers
- [X] Ethernet
- [X] Fan control
- [X] 3 end stops
- [X] "senser"
- [X] RGB LED strip control
- [X] Heated bed
  - [X] Driver
  - [X] Thermocouple
- [X] Power input
- [X] Power regulation
- [X] USB
- [X] UI cable
  - [X] Connector
  - [X] OLED panel (UG-5664ALBEF01)
  - [X] Beeper
  - [X] Rotary encoder
  - [X] SD card
- [X] Extruder cable
  - [X] Connector (1-281742-2)
  - [X] Stepper
  - [X] Heater
  - [X] Thermocouple
  - [X] Fans
- [X] ICSP: UART
- [X] Filament sensor
- [X] LEDs
  - [X] GPIOs
  - [X] Voltage rail
  - [X] Heaters

## Version 1: Order list
| Description                                | MPN                   | QTY |
|--------------------------------------------|-----------------------|-----|
| Extruder cable connector                   | 1-281742-2            | 1   |
| Heated bed connector                       | 1744428-4             | 1   |
| LCD connector                              | 302-S201              | 1   |
| Ethernet jack                              | ARJM11D7-009-AB-ER2-T | 1   |
| End switch + FAN + HB thermistor connector | B2B-XH-AM(LF)(SN)     | 5   |
| Diode                                      | BAT60AE6327HTSA1      | 2   |
| 470pF 0402                                 | C0402C471K5RACTU      | 2   |
| 22nF 0402                                  | GRM155R71H223KA12J    | 4   |
| 100 Ohm 0402                               | CRG0402F100R          | 2   |
| 10 kOhm 0402                               | CRG0402F10K           | 26  |
| 1 kOhm 0402                                | CRG0402F1K            | 3   |
| 1.5 kOhm 0402                              | CRG0402F1K5           | 2   |
| 1 Mohm 0402                                | CRG0402F1M            | 1   |
| 22 Ohm 0402                                | CRG0402F22R           | 4   |
| 2.4 kOhm 0402                              | CRG0402F2K4           | 1   |
| 33 Ohm 0402                                | CRG0402F33R           | 2   |
| 4.7 kOhm 0402                              | CRG0402F4K7           | 2   |
| 50 Ohm 0402                                | CRG0402F50R           | 4   |
| 12MHz crystal                              | CX3225SB12000H0PSTC1  | 1   |
| 25MHz crystal                              | CX3225SB25000H0FLJCC  | 1   |
| 12.1 kOhm                                  | ERJ-2RKF1212X         | 1   |
| Push buttons                               | EVQ-Q2Y03W            | 2   |
| 12pF 0402                                  | GRM1555C1E120GA01D    | 10  |
| 4.7uF 0402                                 | GRM155R61A475MEAAD    | 13  |
| 100nF 0402                                 | GRM155R61H104KE19D    | 45  |
| 10uF 0805                                  | GRM21BR6YA106ME43L    | 8   |
| Current sense resistor 0.1 Ohm 1206        | KRL1632E-M-R100-F-T5  | 8   |
| LM5551                                     | LM5111-1MX/NOPB       | 1   |
| LPC1768                                    | "LPC1769FBD100,551"   | 1   |
| LEDs 0603                                  | LTST-C190TBKT         | 7   |
| Inductor                                   | MLZ1608A1R0WT000      | 1   |
| PCA9306DCTR                                | PCA9306DCTR           | 1   |
| 6 pin header                               | PPTC061LFBN-RC        | 1   |
| Power MOSFET                               | SIJA58DP              | 2   |
| N-Ch MOSFET                                | "SSM3K329R,LF"        | 6   |
| Stepper driver                             | TMC2209-LA            | 4   |
| 220uF elcaps                               | UCW1V221MNL1GS        | 8   |
| Stepper + RGB + filament sensor connectors | B4B-XH-A(LF)(SN)      | 5   |
| USB-C female connector                     | DX07S024XJ1R1100      | 1   |
| Power connector                            | 282814-4              | 1   |
| Power module                               | TPSM53602             | 1   |
| P-Ch MOSFET                                | DMP3099L-13           | 1   |
| Ethernet PHY                               | LAN8720A-CP-TR-ABC    | 1   |
| Inverter                                   | 74HC1G04              | 1   |
| 3.3V regulator                             | NCP5661MN33T2G        | 1   |
| Senser connector                           | B3B-XH-A(LF)(SN)      | 1   |

## EAGLE design board/olchanowski.brd

Parts:
C1, C2: C; 0402; MPN GRM1555C1E120GA01D
C39, C40, C41, C42, C43, C44, C45, C46: C; 0402; MPN GRM155R61H104KE19D
IC1: LPC1768; LQFP100-14X14; MPN LPC1769FBD100,551
L1: L-USL0603; L0603; MPN MLZ1608A1R0WT000
Q1: 12MHz; CX3225SB; MPN CX3225SB12000H0PSTC1
R39, R40: R-US_R0402; R0402; MPN CRG0402F10K
R56: R-US_R0402; R0402; MPN CRG0402F1K
SV1: ICSP; FE06; MPN PPTC061LFBN-RC
SW1, SW2: SPST-2-4PIN; EVQ-Q2; MPN EVQ-Q2Y03W

Connections:
+3V3: C40.2, C41.2, C42.2, C43.2, C44.2, C45.2, C46.2, IC1.19 (VBAT), IC1.28 (VDD(3V3)1), IC1.42 (VDD(REG)(3V3)1), IC1.54 (VDD(3V3)2), IC1.71 (VDD(3V3)3), IC1.84 (VDD(REG)(3V3)2), IC1.96 (VDD(3V3)4), L1.2, R39.2, R40.2, SV1.3; also elsewhere on the board
BTN: IC1.85 (P4[29]/TX_MCLK/MAT2[1]/RXD3); also elsewhere on the board
BUZZER_GATE: IC1.82 (P4[28]/RX_MCLK/MAT2[0]/TXD3); also elsewhere on the board
CTS: SV1.2
DN: IC1.30 (P0[30]/USB_DMINUS); also elsewhere on the board
DP: IC1.29 (P0[29]/USB_DPLUS); also elsewhere on the board
ENET_CRS: IC1.92 (P1[8]/ENET_CRS); also elsewhere on the board
ENET_MDC: IC1.87 (P1[16]/ENET_MDC); also elsewhere on the board
ENET_MDIO: IC1.86 (P1[17]/ENET_MDIO); also elsewhere on the board
ENET_REF_CLK: IC1.88 (P1[15]/ENET_REF_CLK); also elsewhere on the board
ENET_RXD0: IC1.91 (P1[9]/ENET_RXD0); also elsewhere on the board
ENET_RXD1: IC1.90 (P1[10]/ENET_RXD1); also elsewhere on the board
ENET_RX_ER: IC1.89 (P1[14]/ENET_RX_ER); also elsewhere on the board
ENET_TXD0: IC1.95 (P1[0]/ENET_TXD0); also elsewhere on the board
ENET_TXD1: IC1.94 (P1[1]/ENET_TXD1); also elsewhere on the board
ENET_TX_EN: IC1.93 (P1[4]/ENET_TX_EN); also elsewhere on the board
EXTR_HEATER_EN: IC1.66 (P2[7]/RD2/RTS1); also elsewhere on the board
EXTR_TEMP: IC1.8 (P0[24]/AD0[1]/I2SRX_WS/CAP3[1]); also elsewhere on the board
FAN1_EN: IC1.52 (P2[11]/EINT1/I2STX_CLK); also elsewhere on the board
FAN2_EN: IC1.51 (P2[12]/EINT2/I2STX_WS); also elsewhere on the board
FAN_EN: IC1.69 (P2[4]/PWM1[5]/DSR1/TRACEDATA[1]); also elsewhere on the board
GND: C1.2, C2.2, C39.1, C40.1, C41.1, C42.1, C43.1, C44.1, C45.1, C46.1, IC1.11 (VSSA), IC1.15 (VREFN), IC1.31 (VSS1), IC1.41 (VSS2), IC1.55 (VSS3), IC1.72 (VSS4), IC1.83 (VSS6), IC1.97 (VSS5), Q1.GND1 (2), Q1.GND2 (2), SV1.1, SW1.A, SW1.A' (P1), SW2.A, SW2.A' (P1); also elsewhere on the board
HB_EN: IC1.68 (P2[5]/PWM1[6]/DTR1/TRACEDATA[0]); also elsewhere on the board
HB_TEMP: IC1.9 (P0[23]/AD0[0]/I2SRX_CLK/CAP3[0]); also elsewhere on the board
LCD_CS_N: IC1.63 (P0[16]/RXD1/SSEL0/SSEL); also elsewhere on the board
LCD_D/C_N: IC1.44 (P1[28]/MCOA2/PCAP1[0]/MAT0[0]); also elsewhere on the board
LCD_PWR_EN: IC1.45 (P1[29]/MCOB2/PCAP1[1]/MAT0[1]); also elsewhere on the board
LCD_RES_N: IC1.21 (P1[30]/VBUS/AD0[4]); also elsewhere on the board
LCD_SCLK: IC1.62 (P0[15]/TXD1/SCK0/SCK); also elsewhere on the board
LCD_SDIN: IC1.60 (P0[18]/DCD1/MOSI0/MOSI); also elsewhere on the board
LED1: IC1.7 (P0[25]/AD0[2]/I2SRX_SDA/TXD3); also elsewhere on the board
LED2: IC1.6 (P0[26]/AD0[3]/AOUT/RXD3); also elsewhere on the board
LED3: IC1.61 (P0[17]/CTS1/MISO0/MISO); also elsewhere on the board
LED4: IC1.20 (P1[31]/SCK1/AD0[5]); also elsewhere on the board
unnamed: C1.1, IC1.23 (XTAL2), Q1.XTAL1 (1)
unnamed: C2.1, IC1.22 (XTAL1), Q1.XTAL2 (3)
unnamed: C39.2, IC1.10 (VDDA), IC1.12 (VREFP), L1.1
unnamed: IC1.48 (P0[10]/TXD2/SDA2/MAT3[0]), R56.1
RESET: IC1.17 (RESET), R40.1, SW2.B (S), SW2.B' (S1)
RGB_B: IC1.34 (P1[20]/MCI0/PWM1[2]/SCK0); also elsewhere on the board
RGB_G: IC1.33 (P1[19]/MCOA0/USB_PPWR/CAP1[1]); also elsewhere on the board
RGB_R: IC1.32 (P1[18]/USB_UP_LED/PWM1[1]/CAP1[0]); also elsewhere on the board
ROT_A: IC1.35 (P1[21]/MCABORT/PWM1[3]/SSEL0); also elsewhere on the board
ROT_B: IC1.36 (P1[22]/MCOB0/USB_PWRD/MAT1[0]); also elsewhere on the board
RSTOUT: IC1.14 (RSTOUT); also elsewhere on the board
RTS: SV1.6
RX: IC1.99 (P0[3]/RXD0/AD0[6]), SV1.4
SCL: IC1.47 (P0[1]/TD1/RXD3/SCL1); also elsewhere on the board
SDA: IC1.46 (P0[0]/RD1/TXD3/SDA1); also elsewhere on the board
SD_CLK: IC1.78 (P0[7]/I2STX_CLK/SCK1/MAT2[1]); also elsewhere on the board
SD_CS: IC1.79 (P0[6]/I2SRX_SDA/SSEL1/MAT2[0]); also elsewhere on the board
SD_MISO: IC1.77 (P0[8]/I2STX_WS/MISO1/MAT2[2]); also elsewhere on the board
SD_MOSI: IC1.76 (P0[9]/I2STX_SDA/MOSI1/MAT2[3]); also elsewhere on the board
SENSER_CONN: IC1.27 (P3[25]/MAT0[0]/PWM1[2]); also elsewhere on the board
SENSER_PROBE: IC1.26 (P3[26]/STCLK/MAT0[1]/PWM1[3]); also elsewhere on the board
SW_ISP: IC1.53 (P2[10]/EINT0/NMI), R39.1, SW1.B (S), SW1.B' (S1)
TMC_DIR_E: IC1.56 (P0[22]/RTS1/TD1); also elsewhere on the board
TMC_DIR_X: IC1.38 (P1[24]/MCI2/PWM1[5]/MOSI0); also elsewhere on the board
TMC_DIR_Y: IC1.80 (P0[5]/I2SRX_WS/TD2/CAP2[1]); also elsewhere on the board
TMC_DIR_Z: IC1.58 (P0[20]/DTR1/SCL1); also elsewhere on the board
TMC_ENN_E: IC1.57 (P0[21]/RI1/RD1); also elsewhere on the board
TMC_ENN_X: IC1.37 (P1[23]/MCI1/PWM1[4]/MISO0); also elsewhere on the board
TMC_ENN_Y: IC1.81 (P0[4]/I2SRX_CLK/RD2/CAP2[0]); also elsewhere on the board
TMC_ENN_Z: IC1.59 (P0[19]/DSR1/SDA1); also elsewhere on the board
TMC_STEP_E: IC1.70 (P2[3]/PWM1[4]/DCD1/TRACEDATA[2]); also elsewhere on the board
TMC_STEP_X: IC1.73 (P2[2]/PWM1[3]/CTS1/TRACEDATA[3]); also elsewhere on the board
TMC_STEP_Y: IC1.74 (P2[1]/PWM1[2]/RXD1); also elsewhere on the board
TMC_STEP_Z: IC1.75 (P2[0]/PWM1[1]/TXD1); also elsewhere on the board
TMC_UART: IC1.49 (P0[11]/RXD2/SCL2/MAT3[1]), R56.2; also elsewhere on the board
TX: IC1.98 (P0[2]/TXD0/AD0[7]), SV1.5
USB_CONNECT: IC1.64 (P2[9]/USB_CONNECT/RXD2/ENET_MDIO); also elsewhere on the board
X_END: IC1.39 (P1[25]/MCOA1/MAT1[1]); also elsewhere on the board
Y_END: IC1.40 (P1[26]/MCOB1/PWM1[6]/CAP0[0]); also elsewhere on the board
Z_END: IC1.43 (P1[27]/CLKOUT/USB_OVRCR/CAP0[1]); also elsewhere on the board

Notes on the sheet:
CONTROLLER
ICSP
FILTERING
RESET

Parts:
C3, C12: C; 0402; MPN GRM155R71H223KA12J
C4, C5, C6, C8, C9, C10, C13, C14, C15, C17, C18, C19: C; 0402; MPN GRM155R61H104KE19D
C7, C16: CPOL-EU150CLZ-0810; 150CLZ-0810; MPN UCW1V221MNL1GS
C11, C20: C; 0402; MPN GRM155R61A475MEAAD
J1: X-AXIS; JST_B4B-XH-A(LF)(SN)
J2: Y-AXIS; JST_B4B-XH-A(LF)(SN)
R1, R2, R4, R5: R-US_R1206; R1206; MPN KRL1632E-M-R100-F-T5
R3, R10: R-US_R0402; R0402; MPN CRG0402F10K
U1, U2: TMC2209-LA; QFN28-5X5-XLEP

Connections:
+3V3: C8.2, C17.2, R3.2, R10.2, U1.15 (VCC_IO), U2.9 (MS1_ADO), U2.15 (VCC_IO); also elsewhere on the board
+24V: C4.2, C5.2, C6.2, C7.+, C13.2, C14.2, C15.2, C16.+, U1.22 (VS), U1.28 (VS), U2.22 (VS), U2.28 (VS); also elsewhere on the board
GND: C5.1, C6.1, C7.-, C8.1, C9.1, C10.1, C11.1, C14.1, C15.1, C16.-, C17.1, C18.1, C19.1, C20.1, R1.2, R2.2, R4.2, R5.2, U1.3 (GND), U1.9 (MS1_ADO), U1.10 (MS2_AD2), U1.13 (CLK), U1.18 (GND), U1.25 (NU), U1.P1 (PAD), U2.3 (GND), U2.10 (MS2_AD2), U2.13 (CLK), U2.18 (GND), U2.25 (NU), U2.P1 (PAD); also elsewhere on the board
unnamed: C3.2, U1.4 (CPO)
unnamed: C3.1, U1.5 (CPI)
unnamed: C4.1, U1.6 (VCP)
unnamed: C10.2, R1.1, U1.23 (BRA)
unnamed: C9.2, R2.1, U1.27 (BRB)
unnamed: J2.1, U2.1 (OB2)
unnamed: J2.2, U2.26 (OB1)
unnamed: J2.3, U2.24 (OA1)
unnamed: J2.4, U2.21 (OA2)
unnamed: C11.2, U1.8 (5VOUT)
unnamed: C12.2, U2.4 (CPO)
unnamed: C12.1, U2.5 (CPI)
unnamed: C13.1, U2.6 (VCP)
unnamed: C19.2, R4.1, U2.23 (BRA)
unnamed: C18.2, R5.1, U2.27 (BRB)
unnamed: C20.2, U2.8 (5VOUT)
unnamed: J1.4, U1.21 (OA2)
unnamed: J1.3, U1.24 (OA1)
unnamed: J1.2, U1.26 (OB1)
unnamed: J1.1, U1.1 (OB2)
TMC_DIR_X: U1.19 (DIR); also elsewhere on the board
TMC_DIR_Y: U2.19 (DIR); also elsewhere on the board
TMC_ENN_X: R3.1, U1.2 (ENN); also elsewhere on the board
TMC_ENN_Y: R10.1, U2.2 (ENN); also elsewhere on the board
TMC_STEP_X: U1.16 (STEP); also elsewhere on the board
TMC_STEP_Y: U2.16 (STEP); also elsewhere on the board
TMC_UART: U1.14 (PDN_UART), U2.14 (PDN_UART); also elsewhere on the board

Notes on the sheet:
STEPPER DRIVERS (1/2)
For max motor current: 1.92A
UART Addr. 0
X-AXIS
UART Addr. 1
Y-AXIS

Parts:
C21, C30: C; 0402; MPN GRM155R71H223KA12J
C22, C23, C24, C26, C27, C28, C31, C32, C33, C35, C36, C37: C; 0402; MPN GRM155R61H104KE19D
C25, C34: CPOL-EU150CLZ-0810; 150CLZ-0810; MPN UCW1V221MNL1GS
C29, C38: C; 0402; MPN GRM155R61A475MEAAD
J3: Z_AXIS; JST_B4B-XH-A(LF)(SN)
R6, R7, R8, R9: R-US_R1206; R1206; MPN KRL1632E-M-R100-F-T5
R11, R12: R-US_R0402; R0402; MPN CRG0402F10K
U3, U4: TMC2209-LA; QFN28-5X5-XLEP

Connections:
+3V3: C26.2, C35.2, R11.2, R12.2, U3.10 (MS2_AD2), U3.15 (VCC_IO), U4.9 (MS1_ADO), U4.10 (MS2_AD2), U4.15 (VCC_IO); also elsewhere on the board
+24V: C22.2, C23.2, C24.2, C25.+, C31.2, C32.2, C33.2, C34.+, U3.22 (VS), U3.28 (VS), U4.22 (VS), U4.28 (VS); also elsewhere on the board
E_A1: U4.24 (OA1); also elsewhere on the board
E_A2: U4.21 (OA2); also elsewhere on the board
E_B1: U4.26 (OB1); also elsewhere on the board
E_B2: U4.1 (OB2); also elsewhere on the board
GND: C23.1, C24.1, C25.-, C26.1, C27.1, C28.1, C29.1, C32.1, C33.1, C34.-, C35.1, C36.1, C37.1, C38.1, R6.2, R7.2, R8.2, R9.2, U3.3 (GND), U3.9 (MS1_ADO), U3.13 (CLK), U3.18 (GND), U3.25 (NU), U3.P1 (PAD), U4.3 (GND), U4.13 (CLK), U4.18 (GND), U4.25 (NU), U4.P1 (PAD); also elsewhere on the board
unnamed: J3.1, U3.1 (OB2)
unnamed: J3.2, U3.26 (OB1)
unnamed: J3.3, U3.24 (OA1)
unnamed: J3.4, U3.21 (OA2)
unnamed: C21.2, U3.4 (CPO)
unnamed: C21.1, U3.5 (CPI)
unnamed: C22.1, U3.6 (VCP)
unnamed: C28.2, R6.1, U3.23 (BRA)
unnamed: C27.2, R7.1, U3.27 (BRB)
unnamed: C29.2, U3.8 (5VOUT)
unnamed: C30.2, U4.4 (CPO)
unnamed: C30.1, U4.5 (CPI)
unnamed: C31.1, U4.6 (VCP)
unnamed: C37.2, R8.1, U4.23 (BRA)
unnamed: C36.2, R9.1, U4.27 (BRB)
unnamed: C38.2, U4.8 (5VOUT)
TMC_DIR_E: U4.19 (DIR); also elsewhere on the board
TMC_DIR_Z: U3.19 (DIR); also elsewhere on the board
TMC_ENN_E: R12.1, U4.2 (ENN); also elsewhere on the board
TMC_ENN_Z: R11.1, U3.2 (ENN); also elsewhere on the board
TMC_STEP_E: U4.16 (STEP); also elsewhere on the board
TMC_STEP_Z: U3.16 (STEP); also elsewhere on the board
TMC_UART: U3.14 (PDN_UART), U4.14 (PDN_UART); also elsewhere on the board

Notes on the sheet:
STEPPER DRIVERS (2/2)
For max motor current: 1.92A
UART Addr. 2
Z-AXIS
UART Addr. 3
E-AXIS

Parts:
C47, C48, C60, C61, C62, C91: C; 0402; MPN GRM155R61H104KE19D
C49, C50, C51, C52, C53, C54: C; 0402; MPN GRM1555C1E120GA01D
C55, C57, C59, C90: C; 0402; MPN GRM155R61A475MEAAD
C56, C58: C; 0402; MPN C0402C471K5RACTU
J4: ARJM11D7-009-AB-ER2-T; ARJM11D7-009-AB; MPN ARJM11D7-009-AB-ER2-T
Q2: 25MHz; CX3225SB; MPN CX3225SB25000H0FLJCC
R13, R14: R-US_R0402; R0402; MPN CRG0402F100R
R15, R16, R17, R18: R-US_R0402; R0402; MPN CRG0402F50R
R19: R-US_R0402; R0402; MPN CRG0402F1M
R20, R21, R22, R23: R-US_R0402; R0402; MPN CRG0402F22R
R24: R-US_R0402; R0402; MPN CRG0402F1K5
R25, R26: R-US_R0402; R0402; MPN CRG0402F10K
R27: R-US_R0402; R0402; MPN ERJ-2RKF1212X
U5: LAN8720; QFN24; MPN LAN8720A-CP-TR-ABC
U6: 74HC1G04; SOT353

Connections:
+3V3: C47.2, C48.2, C57.2, C58.1, C59.2, C60.2, C61.2, C62.2, C90.2, C91.2, J4.4 (TCT), J4.5 (RCT), R15.1, R16.1, R17.1, R18.1, R24.2, R25.2, U5.1 (VDD2A), U5.9 (VDDIO), U5.19 (VDD1A), U6.5 (P$V+); also elsewhere on the board
ENET_CRS: R21.1; also elsewhere on the board
ENET_LED1: J4.L1 (LED_L_A), U5.3 (LED1/REGOFF)
ENET_LED2: J4.L3 (LED_R_A), R26.2, U5.2 (LED2/!INTSEL)
ENET_MDC: U5.13 (MDC); also elsewhere on the board
ENET_MDIO: R24.1, U5.12 (MDIO); also elsewhere on the board
ENET_REF_CLK: R20.2; also elsewhere on the board
ENET_RXD0: R23.1; also elsewhere on the board
ENET_RXD1: R22.1; also elsewhere on the board
ENET_RX_ER: R25.1, U5.10 (RXER/PHYAD0); also elsewhere on the board
ENET_TXD0: U5.17 (TXD0); also elsewhere on the board
ENET_TXD1: U5.18 (TXD1); also elsewhere on the board
ENET_TX_EN: U5.16 (TXEN); also elsewhere on the board
GND: C47.1, C48.1, C49.2, C50.2, C51.2, C52.2, C53.2, C54.2, C55.1, C56.2, C57.1, C58.2, C59.1, C60.1, C61.1, C62.1, C90.1, C91.1, J4.8 (GND), J4.SH1 (SHIELD1), J4.SH2 (SHIELD2), Q2.GND1 (2), Q2.GND2 (2), R13.1, R14.1, R26.1, R27.1, U5.EXP (VSS), U6.3 (P$V-); also elsewhere on the board
unnamed: C52.1, J4.1 (TD+), R18.2, U5.21 (TXP)
unnamed: C51.1, J4.2 (TD-), R17.2, U5.20 (TXN)
unnamed: C50.1, J4.3 (RD+), R16.2, U5.23 (RXP)
unnamed: C49.1, J4.6 (RD-), R15.2, U5.22 (RXN)
unnamed: J4.L4 (LED_R_C), R13.2
unnamed: J4.L2 (LED_L_C), R14.2
unnamed: U5.14 (REFCLKO/!INT), U6.2 (A)
unnamed: C54.1, Q2.XTAL2 (3), R19.1, U5.5 (XTAL1/CLKIN)
unnamed: C55.2, C56.1, U5.6 (VDDCR)
unnamed: R20.1, U6.4 (Y)
unnamed: R21.2, U5.11 (CRS_DV/MODE2)
unnamed: R22.2, U5.7 (RXD1/MODE1)
unnamed: R23.2, U5.8 (RXD0/MODE0)
unnamed: R27.2, U5.24 (RBIAS)
unnamed: C53.1, Q2.XTAL1 (1), R19.2, U5.4 (XTAL2)
RSTOUT: U5.15 (!RST); also elsewhere on the board

Notes on the sheet:
ETHERNET

Parts:
C63: C; 0402; MPN GRM155R61H104KE19D
C64: C; 0402; MPN GRM155R61A475MEAAD
J5: RGB LED; JST_B4B-XH-A(LF)(SN)
J7: 1744428-4; MPN 1744428-4
Q3, Q4: SIJA58DP; POWERPAK_SO-8L; MPN SIJA58DP
Q5, Q6, Q7, Q8: SSM3K329R,LF; SOT23; MPN SSM3K329R,LF
R28, R29, R30, R31, R32, R33, R34, R35, R36: R-US_R0402; R0402; MPN CRG0402F10K
U7: LM5111; SOIC8; MPN LM5111-1MX/NOPB
X1: X-AXIS; JST-XH-02-PACKAGE-LONG-PAD; MPN B2B-XH
X2: Y-AXIS; JST-XH-02-PACKAGE-LONG-PAD; MPN B2B-XH
X3: Z-AXIS; JST-XH-02-PACKAGE-LONG-PAD; MPN B2B-XH
X4: FAN; JST-XH-02-PACKAGE-LONG-PAD; MPN B2B-XH

Connections:
+3V3: R28.2, R29.2, R30.2; also elsewhere on the board
+5V: C63.2, C64.2, U7.6 (VCC); also elsewhere on the board
+24V: J5.4, J7.1, J7.2, X4.2; also elsewhere on the board
EXTR_HEATER: Q3.D1 (D), Q3.D2 (D), Q3.D3 (D); also elsewhere on the board
EXTR_HEATER_EN: R32.2, U7.4 (INB); also elsewhere on the board
FAN_EN: Q5.1 (G), R33.2; also elsewhere on the board
GND: C63.1, C64.1, Q3.S1 (S), Q3.S2 (S), Q3.S3 (S), Q4.S1 (S), Q4.S2 (S), Q4.S3 (S), Q5.2 (S), Q6.2 (S), Q7.2 (S), Q8.2 (S), R31.1, R32.1, R33.1, R34.1, R35.1, R36.1, U7.3 (VEE), X1.1, X2.1, X3.1; also elsewhere on the board
HB_EN: R31.2, U7.2 (INA); also elsewhere on the board
LED_B: J5.1, Q6.3 (D)
LED_G: J5.3, Q8.3 (D)
LED_R: J5.2, Q7.3 (D)
unnamed: Q4.G, U7.7 (OUTA)
unnamed: Q3.G, U7.5 (OUTB)
unnamed: Q5.3 (D), X4.1
unnamed: J7.3, J7.4, Q4.D1 (D), Q4.D2 (D), Q4.D3 (D)
RGB_B: Q6.1 (G), R34.2; also elsewhere on the board
RGB_G: Q8.1 (G), R36.2; also elsewhere on the board
RGB_R: Q7.1 (G), R35.2; also elsewhere on the board
X_END: R28.1, X1.2; also elsewhere on the board
Y_END: R29.1, X2.2; also elsewhere on the board
Z_END: R30.1, X3.2; also elsewhere on the board

Notes on the sheet:
END STOPS
HEATER DRIVERS
TODO: Find connectors
FAN
RGB STRIP

Parts:
C65, C69, C77, C81: CPOL-EU150CLZ-0810; 150CLZ-0810; MPN UCW1V221MNL1GS
C66, C67, C70, C71, C73, C74, C75, C76: 10u; C0805; MPN GRM21BR6YA106ME43L
C68, C72: C; 0402; MPN GRM155R61H104KE19D
D1: BAT60A; SOD323_ST; MPN BAT60AE6327HTSA1
J8: 282814-4
P1: TPSM53602; B3QFN
R37, R41, R42, R43: R-US_R0402; R0402; MPN CRG0402F10K
R38: R-US_R0402; R0402; MPN CRG0402F2K4
U8: NCP5661-0; DFN6
X5: LCD; PAK100/2500-20; MPN 302-S201

Connections:
+3V3: C74.1, C75.1, C77.+, R41.2, R42.2, R43.2, U8.5 (VOUT), X5.2, X5.20; also elsewhere on the board
+5V: C69.+, C73.1, C76.1, D1.C, U8.1 (EN), U8.2 (VIN), U8.3 (VIN); also elsewhere on the board
+24V: C65.+, C66.1, C67.1, C68.2, C81.+, J8.1, J8.3, P1.1 (VIN), P1.2 (EN), P1.14 (VIN); also elsewhere on the board
BTN: R43.1, X5.9; also elsewhere on the board
BUZZER_GATE: X5.3; also elsewhere on the board
GND: C65.-, C66.2, C67.2, C68.1, C69.-, C70.2, C71.2, C72.1, C73.2, C74.2, C75.2, C76.2, C77.-, C81.-, J8.2, J8.4, P1.3 (NC), P1.10 (NC), P1.11 (NC), P1.12 (AGND), P1.GND1 (AGND), P1.GND2 (PGND), P1.GND3 (PGND), P1.GND4 (PGND), P1.GND5 (PGND), P1.GND6 (PGND), P1.GND7 (PGND), P1.GND8 (PGND), P1.GND9 (PGND), P1.GND10 (PGND), P1.GND11 (PGND), P1.GND12 (PGND), P1.GND13 (PGND), P1.GND14 (PGND), R38.2, U8.4 (GND), U8.PAD (GND1), X5.1, X5.4, X5.10, X5.19; also elsewhere on the board
LCD_CS_N: X5.14; also elsewhere on the board
LCD_D/C_N: X5.16; also elsewhere on the board
LCD_PWR_EN: X5.17; also elsewhere on the board
LCD_RES_N: X5.18; also elsewhere on the board
LCD_SCLK: X5.13; also elsewhere on the board
LCD_SDIN: X5.15; also elsewhere on the board
unnamed: P1.9 (FB), R37.2, R38.1
unnamed: C70.1, C71.1, C72.2, D1.A, P1.7 (VOUT), P1.8 (VOUT), R37.1
ROT_A: R41.1, X5.11; also elsewhere on the board
ROT_B: R42.1, X5.12; also elsewhere on the board
SD_CLK: X5.5; also elsewhere on the board
SD_CS: X5.6; also elsewhere on the board
SD_MISO: X5.8; also elsewhere on the board
SD_MOSI: X5.7; also elsewhere on the board

Notes on the sheet:
POWER
SMPS MODULE: 24V -> 5V
LDO: 5V -> 3.3V
USER INTERFACE
Normal: floating. Pressed: GND
Seems connected to N-trans gate via 410Ohm
Floating / GND
Already has 5k pullup
All LCD pins seem to have the right amount of pull-ups and pull-downs. Nice.
CONNECTOR
ROTARY ENCODER
24V INPUT

Parts:
C78, C79: C; 0402; MPN GRM1555C1E120GA01D
C80: C; 0402; MPN GRM155R61A475MEAAD
C85, C86: C; 0402; MPN GRM155R61H104KE19D
D2: BAT60A; SOD323_ST; MPN BAT60AE6327HTSA1
J6: USB-C-FEMALE; DX07S024XJ1R1100
MNT1, MNT2, MNT3, MNT4, MNT5: MOUNT; MOUNT-M3
Q9: PFETSM; SOT23-3; MPN DMP3099L-13
R44, R45: R-US_R0402; R0402; MPN CRG0402F33R
R46: R-US_R0402; R0402; MPN CRG0402F1K5
R47, R52, R53: R-US_R0402; R0402; MPN CRG0402F10K
R50, R51: R-US_R0402; R0402; MPN CRG0402F1K
X6: HB THERM; JST-XH-02-PACKAGE-LONG-PAD; MPN B2B-XH
X7: SENSER; JST-XH-03-PACKAGE-LONG-PAD

Connections:
+3V3: Q9.3 (D), R47.2, R52.2, R53.2; also elsewhere on the board
+5V: D2.C; also elsewhere on the board
DN: C78.1, R45.1; also elsewhere on the board
DP: C79.1, R44.1, R46.2; also elsewhere on the board
GND: C78.2, C79.2, C80.1, C85.1, C86.1, J6.A1 (GND), J6.A12 (GND), J6.B1 (GND), J6.B12 (GND), J6.S1B (SHIELDA), J6.S1T (SHIELDA), J6.S1TH (SHIELDA), J6.S2B (SHIELDA), J6.S2T (SHIELDA), J6.S2TH (SHIELDA), J6.S3B (SHIELDB), J6.S3T (SHIELDB), J6.S3TH (SHIELDB), J6.S4B (SHIELDB), J6.S4T (SHIELDB), J6.S4TH (SHIELDB), MNT1.MNT, MNT2.MNT, MNT3.MNT, MNT4.MNT, MNT5.MNT, X6.1, X7.2; also elsewhere on the board
HB_TEMP: C80.2, R47.1, X6.2; also elsewhere on the board
unnamed: Q9.2 (S), R46.1
unnamed: C85.2, R50.2, X7.3
unnamed: C86.2, R51.2, X7.1
SENSER_CONN: R51.1, R53.1; also elsewhere on the board
SENSER_PROBE: R50.1, R52.1; also elsewhere on the board
USB_CONNECT: Q9.1 (G); also elsewhere on the board
USB_DN: J6.A7 (D-A), J6.B7 (D-B), R45.2
USB_DP: J6.A6 (D+A), J6.B6 (D+B), R44.2
VUSB: D2.A, J6.A4 (VBUS), J6.A9 (VBUS), J6.B4 (VBUS), J6.B9 (VBUS)

Notes on the sheet:
USB
CONNECTOR
POWER
DATA
TEMPERATURE
HEATED BED
SENSER
AUTOMATIC BED LEVELING
MOUNTING

Parts:
C82, C83, C88: C; 0402; MPN GRM155R61A475MEAAD
C87, C89: C; 0402; MPN GRM155R61H104KE19D
J9: 1-281742-2; MPN 1-281742-2
J10: B4B-XH-A(LF)(SN); JST_B4B-XH-A(LF)(SN)
LED1, LED2, LED3, LED4, LED5, LED6, LED7: LEDCHIP-LED0603; CHIP-LED0603; MPN LTST-C190TBKT
Q10, Q11: SSM3K329R,LF; SOT23; MPN SSM3K329R,LF
R48, R49: R-US_R0402; R0402; MPN CRG0402F10K
R54, R55: R-US_R0402; R0402; MPN CRG0402F4K7
U9: PCA9306DCTR; SOP65P400X130-8N

Connections:
+3V3: C82.2, C87.2, J9.19, LED5.A, R54.2, R55.2, U9.2 (VREF1); also elsewhere on the board
+5V: C88.2, C89.2, J10.1, U9.7 (VREF2), U9.8 (EN); also elsewhere on the board
+24V: J9.7, J9.8, J9.9, J9.10, J9.11; also elsewhere on the board
EXTR_HEATER: J9.12, J9.13, J9.14, J9.15, J9.16; also elsewhere on the board
EXTR_HEATER_EN: LED6.A; also elsewhere on the board
EXTR_TEMP: C83.1, J9.20; also elsewhere on the board
E_A1: J9.4; also elsewhere on the board
E_A2: J9.5; also elsewhere on the board
E_B1: J9.3; also elsewhere on the board
E_B2: J9.6; also elsewhere on the board
FAN1: J9.22, Q10.3 (D)
FAN1_EN: Q10.1 (G), R48.2; also elsewhere on the board
FAN2: J9.21, Q11.3 (D)
FAN2_EN: Q11.1 (G), R49.2; also elsewhere on the board
GND: C82.1, C83.2, C87.1, C88.1, C89.1, J9.17, J9.18, J10.2, LED1.C, LED2.C, LED3.C, LED4.C, LED5.C, LED6.C, LED7.C, Q10.2 (S), Q11.2 (S), R48.1, R49.1, U9.1 (GND); also elsewhere on the board
HB_EN: LED7.A; also elsewhere on the board
LED1: LED1.A; also elsewhere on the board
LED2: LED2.A; also elsewhere on the board
LED3: LED3.A; also elsewhere on the board
LED4: LED4.A; also elsewhere on the board
unnamed: J10.3, U9.6 (SCL2)
unnamed: J10.4, U9.5 (SDA2)
SCL: R55.1, U9.3 (SCL1); also elsewhere on the board
SDA: R54.1, U9.4 (SDA1); also elsewhere on the board

Notes on the sheet:
EXTRUDER CABLE
FAN CONTROL
CONNECTOR
FILAMENT SENSOR
LEDS

Notices in the files:
parts and their libraries:
microchip-smsc-lan8720: (C) 2014 Tomasz Boleslaw CEDRO, cederom@tlen.pl, http://www.tomek.cedro.info.
SparkFun-IC-Logic: Licensing: Creative Commons ShareAlike 4.0 International - https://creativecommons.org/licenses/by-sa/4.0
