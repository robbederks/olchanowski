# Repository robbederks/olchanowski (continued)

## EAGLE design board/olchanowski.brd (continued)

Board: 2 copper layers, 139.4 x 99.4 mm, 203 parts (1 on the bottom side), 151 nets.

## Commit log

2020-04-03 Short readme
2020-04-04 Microcontroller and stepper drivers
2020-04-05 Added ethernet
2020-04-06 Add checklist
2020-04-07 Endstops and heater drivers
2020-04-08 Added filament sensor to TODO
2020-04-08 More schematic stuff
2020-04-09 More schematic work
2020-04-10 More stuff
2020-04-11 Schematic finished!
2020-04-12 Started on board
2020-04-14 Minor schematic improvements and initial routing work
2020-04-15 Component placement
2020-04-15 Example routing for a stepper driver
2020-04-16 More routing
2020-04-17 Routing
2020-04-17 First rev done and ordered!
2020-04-22 Added order list
2020-05-08 Fix label size
2020-05-08 Update Cap P/N
2020-05-08 Fix P1 NC/AGND pins
2020-05-08 Fix Stepper connector pinout
2020-05-08 Add MPN for Q9
2020-05-08 README needs part number too
2020-05-09 Fix Ethernet pinout and LED position
2020-05-09 Move LED3 and LED4 on micro
2020-05-09 Drill hole for JST plus some clean ups
2020-05-14 Swap PROBE and CONN
